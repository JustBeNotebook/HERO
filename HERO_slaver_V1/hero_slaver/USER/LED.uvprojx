# Keil uVision project LED.uvprojx, settings and files
target LED (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\inc;..\USER;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\link;..\SYSTEM\systick;..\SYSTEM\task;..\SOFTWARE\PID;..\SOFTWARE\OFFLINE_JUDGE;..\HARDWARE\LED;..\HARDWARE\Timer;..\HARDWARE\CAN;..\HARDWARE\Motor_Module;..\HARDWARE\DR16;..\HARDWARE\chassis;..\HARDWARE\gimbal;..\CAR\LAUNCHER;..\HARDWARE\dji_judge_Module;..\SOFTWARE\CRC_8_16;..\HARDWARE\my_judge;..\SOFTWARE\top;..\HARDWARE\super_cap;..\HARDWARE\BMI;..\HARDWARE\IMUsensor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c system_stm32f4xx.c stm32f4xx_it.c
  group SOFTWARE
    ../SOFTWARE/PID/: pid.c
    ../SOFTWARE/OFFLINE_JUDGE/: offline_judge.c
    ../SOFTWARE/CRC_8_16/: crc.c
    ../SOFTWARE/top/: top.c
  group HARDWARE
    ../SYSTEM/usart/: usart.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Motor_Module/: Motor.c
    ../HARDWARE/CAN/: CAN.c
    ../HARDWARE/DR16/: dr16.c
    ../HARDWARE/Timer/: timer.c
    ../HARDWARE/my_judge/: my_judge.c
    ../HARDWARE/super_cap/: supercap.c
    ../HARDWARE/IMUsensor/: IMUsensor.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/systick/: systick.c
    ../SYSTEM/link/: link.c
    ../SYSTEM/task/: task.c
  group CAR
    ../HARDWARE/UnKnow_Motor/: unknow_motor.c
    ../CAR/LAUNCHER/: launcher.c
    ../HARDWARE/chassis/: chassis.c
    ../HARDWARE/gimbal/: gimbal.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_wwdg.c
  group README
    ../: readme.txt
  group BMI
    ../HARDWARE/BMI/: bmi.c bmi2.c bmi2_common.c bmi2_ois.c bmi270.c bmi270_context.c iic.c kalman.c myiic.c spi2.c
